# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: OneElfS=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HardWare\LED;..\DSP_Lib;..\HardWare\ADC;..\HardWare\DMA;..\HardWare\TIM;..\SYSTEM\HMI;..\HardWare\KEY;..\SYSTEM\config;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HardWare\Encoder
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/HMI/: hmi.c
  group DSP_Lib
    ../DSP_Lib/: cr4_fft_256_stm32.s
  group HardWare
    ../HardWare/LED/: led.c
    ../HardWare/ADC/: adc.c
    ../HardWare/DMA/: dma.c
    ../HardWare/TIM/: tim.c
    ../HardWare/KEY/: key.c
    ../HardWare/Encoder/: encoder.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: README.TXT
